# Keil uVision project CPU0.uvprojx, settings and files
target CPU0 (6240000::V6.24::ARMCLANG)
  device: M263SIAAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: CPU0 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\Release\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT=UART0
  c include: ..\..\CCC_common\Library\Device\Nuvoton\M261\Include;..\..\CCC_common\Library\StdDriver\inc;..\..\CCC_common\Library\CMSIS\Include;source\driver\include;source\Include;.\source\oled\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../CCC_common/Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../../CCC_common/Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
  group Library
    ../../CCC_common/Library/StdDriver/src/: can.c clk.c fmc.c gpio.c i2c.c retarget.c rtc.c spi.c sys.c timer.c uart.c usci_uart.c wdt.c MKROMLib_Keil.lib
  group User
    source/: main.c
    ./source/: fmc_user.c targetdev.c watchdog.c app.c cmds.c cli.c fifo.c uart_pkts.c bsp.c isp_user.c utils.c event_log.c read_cpu.c
  group hl_driver
    ./source/driver/: drvr_spi.c drvr_uart.c drvr_uuart.c drvr_iic.c
  group oled
    ./source/oled/: fonts.c SH1106.c
